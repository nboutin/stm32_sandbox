# IAR project Project.ewp, settings and files
configuration STM32F411E-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE; USE_STM32F411E_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32F411E-Discovery; ..\..\..\..\Utilities\Log; ..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../../../../Drivers/BSP/Components/i3g4250d/: i3g4250d.c
    ../../../../Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
    ../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c
  group Drivers/BSP/STM32F411E-Discovery
    ../../../../Drivers/BSP/STM32F411E-Discovery/: stm32f411e_discovery.c stm32f411e_discovery_accelerometer.c stm32f411e_discovery_audio.c stm32f411e_discovery_gyroscope.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32f411xe.s
  group Example/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Middlewares/STM32_Audio
    ../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_IAR_wc32.a

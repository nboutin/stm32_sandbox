# Keil uVision project Project.uvprojx, settings and files
target STM32F411E-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411VEHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F411E_DISCO
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STM32F411E_DISCO,USE_HAL_DRIVER
  c include: ../Inc;../../../../Drivers//CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers//STM32F4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F411E-Discovery;../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Middlewares/STM32_USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c usbd_desc.c stm32f4xx_it.c main.c usbd_conf.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
    ../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F411E_DISCO
    ../../../../Drivers/BSP/STM32F411E-Discovery/: stm32f411e_discovery_accelerometer.c stm32f411e_discovery.c
software components: CMSIS:CORE 4.3.0
